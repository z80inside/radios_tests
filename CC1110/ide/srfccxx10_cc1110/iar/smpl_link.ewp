# IAR project smpl_link.ewp, settings and files
configuration srfccxx10_cc1110 (8051, debug)
  General.DerivativeDescriptionFile: $TOOLKIT_DIR$\config\devices\Texas Instruments\CC1110.i51
  ICC8051.CCDefines: MRFI_CC1110; MCU_H="ioCC1110.h"
  ICC8051.CCDiagSuppress: Pe001,Pa084,Pa082
  ICC8051.OCCDataMemoryModel: 1
  ICC8051.OCCCodeMemoryModel: 1
  ICC8051.PreInclude: C:\Documents and Settings\superusuario\Escritorio\Dangerous tests\CC1110\source\apps\options.h
  ICC8051.CCIncludePath2: ../../../source/components\simpliciti\bsp; ../../../source/components\simpliciti\bsp\drivers; ../../../source/components\simpliciti\bsp\boards\SRFCCxx10; ../../../source/components\simpliciti\mrfi; ../../../source/components\simpliciti\simpliciti\nwk; ../../../source/components\simpliciti\simpliciti\nwk_applications
  ICC8051.CCStdIncludePath: $TOOLKIT_DIR$\INC\; $TOOLKIT_DIR$\INC\CLIB\
  ICC8051.CCOptLevel: 3
  ICC8051.CCOptStrategy: 1
  A8051.ADefines: chip=1110
  XLINK.XclFile: lnk51ew_cc1110.xcl
  group (top)
    ../../../source/components/simpliciti/bsp/drivers/code/: uart.c uart_intfc.c
  group components/bsp
    ../../../source/components/simpliciti/bsp/: bsp.c bsp.h bsp_macros.h
    ../../../source/components/simpliciti/bsp/mcus/: bsp_8051_defs.h
    ../../../source/components/simpliciti/bsp/boards/SRFCCxx10/: bsp_board.c bsp_board_defs.h bsp_button_defs.h bsp_driver_defs.h bsp_drivers.c bsp_led_defs.h
    ../../../source/components/simpliciti/bsp/drivers/code/: bsp_buttons.c bsp_generic_buttons.h bsp_generic_leds.h bsp_leds.c
    ../../../source/components/simpliciti/bsp/drivers/: bsp_buttons.h bsp_leds.h
    ../../../source/components/simpliciti/bsp/boards/SRFCCxx10/bsp_external/: mrfi_board_defs.h
  group components/bsp/extended
    ../../../source/apps/: bsp_extended.c bsp_extended.h
  group components/mrfi
    ../../../source/components/simpliciti/mrfi/: mrfi.c mrfi.h mrfi_defs.h
    ../../../source/components/simpliciti/mrfi/smartrf/cc1110/: smartrf_CC1110_srfcc1110.h
    ../../../source/components/simpliciti/mrfi/smartrf/cc2510/: smartrf_cc2510_srfcc2510.h
  group components/mrfi/radios
    ../../../source/components/simpliciti/mrfi/radios/common/: mrfi_f1f2.c mrfi_f1f2.h
    ../../../source/components/simpliciti/mrfi/radios/family2/: mrfi_radio.c
  group components/simpliciti/nwk
    ../../../source/components/simpliciti/simpliciti/nwk/: nwk.c nwk.h nwk_api.c nwk_api.h nwk_app.h nwk_frame.c nwk_frame.h nwk_globals.c nwk_globals.h nwk_QMgmt.c nwk_QMgmt.h nwk_types.h
    ../../../source/components/simpliciti/simpliciti/nwk_applications/: nwk_freq.c nwk_freq.h nwk_ioctl.c nwk_ioctl.h nwk_join.c nwk_join.h nwk_link.c nwk_link.h nwk_mgmt.c nwk_mgmt.h nwk_ping.c nwk_ping.h nwk_security.c nwk_security.h
  group peer applications/application
    ../../../source/apps/: flash_asm.s51 main_basic.c simp_app_cn.c simp_app_en.c
  group peer applications/configuration
    ../../../source/apps/: smpl_config.dat smpl_nwk_config.dat
