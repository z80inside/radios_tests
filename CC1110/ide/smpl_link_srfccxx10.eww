<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\srfccxx10_cc1110\iar\smpl_link.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\srfccxx10_cc2510\iar\smpl_link.ewp</path>
  </project>
</workspace>


